Commit message: add new robot.urdf for test

File: robot.urdf (robot description, URDF)
Before this commit: robot robotAll, 3 links, 2 joints
Joints:
- joint head_to_neck: origin xyz=0 -0.22 0.25 -> xyz=0 -10 0
- joint neck_to_body: origin xyz=0 0.22 0.25 -> xyz=0 -30 0
