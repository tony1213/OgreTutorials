Commit message: modify urdf and clean some code

File: urdf/H3.urdf (robot description, URDF)
Before this commit: robot H3_robot, 18 links, 17 joints
Joints:
- joint torso_joint: origin xyz=0 0 0.2475 rpy=0 0 0 -> xyz=0 0 0 rpy=-1.5707 0 0
